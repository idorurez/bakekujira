# Repository idorurez/bakekujira

File README.md:

# bakekujira

## Features
* TKL, F-row less
* split 
* per-key RGB
* underglow
* Proton-C
* support for 128x32
* QMK

# BOM

Part | Part number | Number needed | Link
------------ | ------------- | ------------- | -------------
 Proton-C | n/a | 2 | https://mkultra.click/qmk-proton-c/ note: EXTREMELY LIMITED stock everywhere, most are gone
 Mill Max low profile Sockets | 315-47-164-41-001000 | X | n/a
 Mill Max pins Pins |  3320-0-00-15-00-00-03-0 | X |  n/a
 LEDs | SK6812MINI-E | 104 (or get as many as you can) | https://www.aliexpress.com/item/4000476037223.html?spm=a2g0s.9042311.0.0.27424c4dQxUpgR 
 TRRS Connectors | MJ-4PP-9 | 2 | https://www.aliexpress.com/item/32368285821.html?spm=a2g0s.9042311.0.0.27424c4dQxUpgR 
 Kailh hot swap sockets | n/a | minimum 74 | https://www.aliexpress.com/item/4001051840976.html?spm=a2g0s.9042311.0.0.27424c4dQxUpgR 
 Tactile Push button | 4x4x1.5mm 4pin SMD | 2 | https://www.aliexpress.com/item/1005001328036177.html?spm=a2g0s.9042311.0.0.27424c4d8ExoPG 
 0805 4.7K resistor | n/a | 2 | https://www.aliexpress.com/item/4000906183506.html?spm=a2g0s.9042311.0.0.27424c4d8ExoPG 
 0805 510R resistor | n/a | 2 | https://www.aliexpress.com/item/4000906183506.html?spm=a2g0s.9042311.0.0.27424c4d8ExoPG 
 0603 100nF (aka 0.1uF) ceramic capacitors | n/a | minimum 104 | https://www.aliexpress.com/item/4000193649637.html?spm=a2g0s.9042311.0.0.27424c4d8ExoPG 
 1N4148 diodes | n/a | minimum 74 | https://www.aliexpress.com/item/4000685043735.html?spm=a2g0s.9042311.0.0.27424c4d8ExoPG 
 
# Software

## Installation
1. clone my fork of qmk_firmware
2. `cd qmk_firmware/`
3. Grab the chibios submodules:
   `git submodule sync —recursive && git submodule update --init —recursive`
4. open up qmk msys
5. `qmk compile -kb bakekujira -km default -bl dfu-util-split-left` (do the right side also, you only have to do this once for each side)

## Notes
* `onigaku` repo (not included in this repo) has all symbols and footprints
* Sorry for not using Kanji, thought Kana had a better overall fit!
* The art design is temporary. I will be changing the mascot to something easier on the eyes.

# Suggestions
* Order more than you need of the diodes, caps, and leds, and kailh sockets. FYI, in most cases there is a MOQ
* The 01.uF capacitors aren't absolutely needed, but it will help with fluctuations and possibly prevent LEDs from burning out.

# Soldering Hints
* It's easier to use a wider/bigger tip in some cases.
* For the small solder pads, make sure you are tinning and using flux to ensure that the very tip of your soldering tip will hold a bead of solder.
* For the Kailh sockets, you can put solder on both pads first and then pushing down on the kailh socket while heating up the ends one at time.

# LEDs
* When soldering the underglow LEDs, bend the terminals/legs down so they touch the soldering pads.
* Solder the LEDs in the order that wired up and test as you go. Please see the diagram (ie solder the under glows first)
* If the LED looks broken or melted, it's probably broken.

## Inspiration
Picked apart a lot of boards, including:
* Corne
* Corne Waffle
* marevelous65 split
* ganymede

## TODO
* build case
* build plate
* working out breakout board for 256x32 (see other SSD1326 breakout repo)

## REV2
* move proton-c and plugs out instead of tucked in line with the top row to allow for more case options
* Add holes for M2x4 or M2x9 screws/standoffs to allow for more case options
* sound and speakers
* oled 256x32, which may end up here under rev1

## Credits
My QMK friends who have not openly judged me on being an idiot (except for xyz):
* Drashna
* foostan
* waffle
* tzarc
* xyz

## KiCad design bakekujira.kicad_pcb

Board: 2 copper layers, 405.8 x 120.8 mm, 366 parts (256 on the bottom side), 219 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102, C103, C104: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D_1, D_2, D_3, D_4, D_5, D_6, D_7, D_8, D_9, D_10, D_11, D_12, D_13, D_14, D_15, D_16, D_17, D_18, D_19, D_20, D_21, D_22, D_23, D_24, D_25, D_26, D_27, D_28, D_29, D_30, D_31, D_32, D_33, D_34, D_35, D_36, D_37, D_38, D_39, D_40, D_41, D_42, D_43, D_44, D_45, D_46, D_47, D_48, D_49, D_50, D_51, D_52, D_53, D_54, D_55, D_56, D_57, D_58, D_59, D_60, D_61, D_62, D_63, D_64, D_65, D_66, D_67, D_68, D_69, D_70, D_71, D_72, D_73: D; D3_SMD_v2
J1, J2: MJ-4PP-9
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED104: YS-SK6812MINI-E; YS-SK6812MINI-E_underglow
LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84, LED85, LED86, LED87, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103: YS-SK6812MINI-E
OL1, OL2: OLED; OLED_v2
R1, R2: 500; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RSW1, RSW2: SW_PUSH; SW_SPST_TL3342
SW_1, SW_2, SW_3, SW_4, SW_5, SW_6, SW_8, SW_9, SW_10, SW_11, SW_12, SW_13, SW_14, SW_15, SW_16, SW_17, SW_18, SW_19, SW_20, SW_21, SW_22, SW_23, SW_24, SW_26, SW_27, SW_28, SW_30, SW_31, SW_32, SW_33, SW_34, SW_35, SW_36, SW_37, SW_38, SW_39, SW_40, SW_43, SW_44, SW_45, SW_46, SW_47, SW_48, SW_49, SW_50, SW_51, SW_52, SW_54, SW_56, SW_57, SW_58, SW_59, SW_60, SW_66, SW_67, SW_68: KEYSW; CherryMX_Hotswap
SW_7: KEYSW; CherryMX_Hotswap_2u_North
SW_25, SW_29: KEYSW; CherryMX_Hotswap_1.5u
SW_41, SW_55: KEYSW; CherryMX_Hotswap_2.25u_North
SW_42: KEYSW; CherryMX_Hotswap_1.75u
SW_53: KEYSW; CherryMX_Hotswap_2.75u_North
SW_61: KEYSW; CherryMX_Hotswap_2.75u_North_reversed_stabilizers
SW_62, SW_63, SW_64, SW_65, SW_69, SW_70, SW_71, SW_72: KEYSW; CherryMX_Hotswap_1.25u_North
SW_73: KEYSW; CherryMX_Hotswap_2.25u_North_reversed_stabilizers
U1, U2: proton_c

Connections:
GND: C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C86.2, C87.2, C88.2, C89.2, C90.2, C99.2, C100.2, C101.2, C102.2, C103.2, J2.2, LED7.3, LED8.3, LED9.3, LED10.3, LED11.3, LED12.3, LED13.3, LED26.3, LED27.3, LED28.3, LED29.3, LED30.3, LED41.3, LED42.3, LED43.3, LED44.3, LED45.3, LED46.3, LED47.3, LED59.3, LED60.3, LED61.3, LED62.3, LED63.3, LED64.3, LED72.3, LED73.3, LED74.3, LED75.3, LED76.3, LED77.3, LED78.3, LED86.3, LED87.3, LED88.3, LED89.3, LED90.3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
GNDA: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C14.2, C20.1, C21.2, C22.1, C23.1, C24.2, C25.1, C26.2, C27.2, C28.1, C29.1, C30.1, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C104.2, J1.2, LED1.3, LED2.3, LED3.3, LED4.3, LED5.3, LED6.3, LED14.3, LED15.3, LED16.3, LED17.3, LED18.3, LED19.3, LED20.3, LED21.3, LED22.3, LED23.3, LED24.3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
LED_L: R2.2, U2.A3|5v
LED_R: R1.2, U1.A3|5v
unnamed: D_1.2, SW_1.2
unnamed: D_2.2, SW_2.2
unnamed: D_3.2, SW_3.2
unnamed: D_4.2, SW_4.2
unnamed: D_5.2, SW_5.2
unnamed: D_6.2, SW_6.2
unnamed: D_7.2, SW_7.2
unnamed: D_8.2, SW_8.2
unnamed: D_9.2, SW_9.2
unnamed: D_10.2, SW_10.2
unnamed: D_11.2, SW_11.2
unnamed: D_12.2, SW_12.2
unnamed: D_13.2, SW_13.2
unnamed: D_14.2, SW_14.2
unnamed: D_15.2, SW_15.2
unnamed: D_16.2, SW_16.2
unnamed: D_17.2, SW_17.2
unnamed: D_18.2, SW_18.2
unnamed: D_19.2, SW_19.2
unnamed: D_20.2, SW_20.2
unnamed: D_21.2, SW_21.2
unnamed: D_22.2, SW_22.2
unnamed: D_23.2, SW_23.2
unnamed: D_24.2, SW_24.2
unnamed: D_25.2, SW_25.2
unnamed: D_26.2, SW_26.2
unnamed: D_27.2, SW_27.2
unnamed: D_28.2, SW_28.2
unnamed: D_29.2, SW_29.2
unnamed: D_30.2, SW_30.2
unnamed: D_31.2, SW_31.2
unnamed: D_32.2, SW_32.2
unnamed: D_33.2, SW_33.2
unnamed: D_34.2, SW_34.2
unnamed: D_35.2, SW_35.2
unnamed: D_36.2, SW_36.2
unnamed: D_37.2, SW_37.2
unnamed: D_38.2, SW_38.2
unnamed: D_39.2, SW_39.2
unnamed: D_40.2, SW_40.2
unnamed: D_41.2, SW_41.2
unnamed: D_42.2, SW_42.2
unnamed: D_43.2, SW_43.2
unnamed: D_44.2, SW_44.2
unnamed: D_45.2, SW_45.2
unnamed: D_46.2, SW_46.2
unnamed: D_47.2, SW_47.2
unnamed: D_48.2, SW_48.2
unnamed: D_49.2, SW_49.2
unnamed: D_50.2, SW_50.2
unnamed: D_51.2, SW_51.2
unnamed: D_52.2, SW_52.2
unnamed: D_53.2, SW_53.2
unnamed: D_54.2, SW_54.2
unnamed: D_55.2, SW_55.2
unnamed: D_56.2, SW_56.2
unnamed: D_57.2, SW_57.2
unnamed: D_58.2, SW_58.2
unnamed: D_59.2, SW_59.2
unnamed: D_60.2, SW_60.2
unnamed: D_61.2, SW_61.2
unnamed: D_62.2, SW_62.2
unnamed: D_63.2, SW_63.2
unnamed: D_64.2, SW_64.2
unnamed: D_65.2, SW_65.2
unnamed: D_66.2, SW_66.2
unnamed: D_67.2, SW_67.2
unnamed: D_68.2, SW_68.2
unnamed: D_69.2, SW_69.2
unnamed: D_70.2, SW_70.2
unnamed: D_71.2, SW_71.2
unnamed: D_72.2, SW_72.2
unnamed: D_73.2, SW_73.2
unnamed: LED1.2, LED104.4
unnamed: LED1.4, LED14.2
unnamed: LED2.2, LED3.4
unnamed: LED3.2, LED4.4
unnamed: LED4.2, LED5.4
unnamed: LED5.2, LED6.4
unnamed: LED7.4, LED8.2
unnamed: LED8.4, LED9.2
unnamed: LED9.4, LED10.2
unnamed: LED10.4, LED11.2
unnamed: LED11.4, LED12.2
unnamed: LED12.4, LED13.2
unnamed: LED13.4, LED30.2
unnamed: LED14.4, LED15.2
unnamed: LED15.4, LED16.2
unnamed: LED16.4, LED17.2
unnamed: LED17.4, LED18.2
unnamed: LED18.4, LED19.2
unnamed: LED19.4, LED20.2
unnamed: LED20.4, LED21.2
unnamed: LED21.4, LED22.2
unnamed: LED22.4, LED23.2
unnamed: LED23.4, LED24.2
unnamed: LED24.4, LED25.2
unnamed: LED25.4, R1.1
unnamed: LED26.2, LED27.4
unnamed: LED26.4, R2.1
unnamed: LED27.2, LED28.4
unnamed: LED28.2, LED29.4
unnamed: LED29.2, LED30.4
unnamed: LED31.2, LED48.4
unnamed: LED31.4, LED32.2
unnamed: LED32.4, LED49.2
unnamed: LED33.2, LED50.4
unnamed: LED33.4, LED34.2
unnamed: LED34.4, LED51.2
unnamed: LED35.2, LED52.4
unnamed: LED35.4, LED36.2
unnamed: LED36.4, LED53.2
unnamed: LED37.2, LED54.4
unnamed: LED37.4, LED55.2
unnamed: LED38.2, LED56.4
unnamed: LED38.4, LED39.2
unnamed: LED39.4, LED57.2
unnamed: LED40.2, LED58.4
unnamed: LED6.2, LED40.4
unnamed: LED41.2, LED59.4
unnamed: LED7.2, LED41.4
unnamed: LED42.2, LED43.4
unnamed: LED42.4, LED73.2
unnamed: LED43.2, LED60.4
unnamed: LED44.2, LED45.4
unnamed: LED44.4, LED61.2
unnamed: LED45.2, LED62.4
unnamed: LED46.2, LED47.4
unnamed: LED46.4, LED63.2
unnamed: LED47.2, LED64.4
unnamed: LED48.2, LED65.4
unnamed: LED49.4, LED66.2
unnamed: LED50.2, LED67.4
unnamed: LED51.4, LED68.2
unnamed: LED52.2, LED69.4
unnamed: LED53.4, LED70.2
unnamed: LED54.2, LED71.4
unnamed: LED55.4, LED95.2
unnamed: LED56.2, LED96.4
unnamed: LED57.4, LED85.2
unnamed: LED58.2, LED98.4
unnamed: LED59.2, LED72.4
unnamed: LED60.2, LED74.4
unnamed: LED61.4, LED75.2
unnamed: LED62.2, LED76.4
unnamed: LED63.4, LED77.2
unnamed: LED64.2, LED78.4
unnamed: LED65.2, LED79.4
unnamed: LED66.4, LED80.2
unnamed: LED67.2, LED81.4
unnamed: LED68.4, LED82.2
unnamed: LED69.2, LED83.4
unnamed: LED70.4, LED94.2
unnamed: LED71.2, LED84.4
unnamed: LED72.2, LED99.4
unnamed: LED74.2, LED86.4
unnamed: LED75.4, LED87.2
unnamed: LED76.2, LED88.4
unnamed: LED77.4, LED89.2
unnamed: LED78.2, LED90.4
unnamed: LED79.2, LED91.4
unnamed: LED80.4, LED81.2
unnamed: LED82.4, LED92.2
unnamed: LED83.2, LED93.4
unnamed: LED84.2, LED94.4
unnamed: LED85.4, LED97.2
unnamed: LED88.2, LED89.4
unnamed: LED92.4, LED93.2
unnamed: LED95.4, LED96.2
unnamed: LED97.4, LED98.2
unnamed: LED73.4, LED100.2
unnamed: LED99.2, LED100.4
unnamed: LED101.2, LED102.4
unnamed: LED86.2, LED101.4
unnamed: LED87.4, LED102.2
unnamed: LED90.2, LED103.4
unnamed: LED2.4, LED104.2
SCL_L: OL2.2, U2.B6
SCL_R: OL1.2, U1.B6
SDA_L: OL2.1, U2.B7
SDA_R: OL1.1, U1.B7
VCC: C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C86.1, C87.1, C88.1, C89.1, C90.1, C99.1, C100.1, C101.1, C102.1, C103.1, J2.1, LED7.1, LED8.1, LED9.1, LED10.1, LED11.1, LED12.1, LED13.1, LED26.1, LED27.1, LED28.1, LED29.1, LED30.1, LED41.1, LED42.1, LED43.1, LED44.1, LED45.1, LED46.1, LED47.1, LED59.1, LED60.1, LED61.1, LED62.1, LED63.1, LED64.1, LED72.1, LED73.1, LED74.1, LED75.1, LED76.1, LED77.1, LED78.1, LED86.1, LED87.1, LED88.1, LED89.1, LED90.1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
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C14.1, C20.2, C21.1, C22.2, C23.2, C24.1, C25.2, C26.1, C27.1, C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, C91.1, C92.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C104.1, J1.1, LED1.1, LED2.1, LED3.1, LED4.1, LED5.1, LED6.1, LED14.1, LED15.1, LED16.1, LED17.1, LED18.1, LED19.1, LED20.1, LED21.1, LED22.1, LED23.1, LED24.1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
col0_L: SW_11.1, SW_29.1, SW_42.1, SW_69.1, U2.A2
col0_R: SW_1.1, SW_18.1, SW_35.1, SW_48.1, SW_61.1, U1.B12
col1_L: SW_12.1, SW_55.1, SW_70.1, U2.A1
col1_R: SW_2.1, SW_19.1, SW_36.1, SW_49.1, U1.B11
col2_L: SW_13.1, SW_30.1, SW_43.1, SW_56.1, SW_71.1, U2.A0
col2_R: SW_3.1, SW_20.1, SW_37.1, SW_50.1, U1.B10
col3_L: SW_14.1, SW_31.1, SW_44.1, SW_57.1, SW_72.1, U2.B8
col3_R: SW_4.1, SW_21.1, SW_38.1, SW_51.1, SW_62.1, U1.B9
col4_L: SW_15.1, SW_32.1, SW_45.1, SW_58.1, U2.B13
col4_R: SW_5.1, SW_22.1, SW_39.1, SW_52.1, SW_63.1, U1.B15
col5_L: SW_16.1, SW_33.1, SW_46.1, SW_59.1, U2.B14
col5_R: SW_6.1, SW_23.1, SW_40.1, U1.B14
col6_L: SW_17.1, SW_34.1, SW_47.1, SW_60.1, SW_73.1, U2.B15
col6_R: SW_24.1, SW_41.1, SW_53.1, SW_64.1, U1.B13
col7_R: SW_7.1, SW_25.1, SW_65.1, U1.B8
col8_R: SW_8.1, SW_26.1, SW_66.1, U1.A0
col9_R: SW_9.1, SW_27.1, SW_54.1, SW_67.1, U1.A1
col10_R: SW_10.1, SW_28.1, SW_68.1, U1.A2
data_L: J2.4, R3.2, U2.A9
data_R: J1.4, R4.2, U1.A9
reset_L: RSW2.1, U2.DFU
reset_R: RSW1.1, U1.DFU
row0_L: D_11.1, D_12.1, D_13.1, D_14.1, D_15.1, D_16.1, D_17.1, U2.B5
row0_R: D_1.1, D_2.1, D_3.1, D_4.1, D_5.1, D_6.1, D_7.1, D_8.1, D_9.1, D_10.1, U1.B5
row1_L: D_29.1, D_30.1, D_31.1, D_32.1, D_33.1, D_34.1, U2.B4
row1_R: D_18.1, D_19.1, D_20.1, D_21.1, D_22.1, D_23.1, D_24.1, D_25.1, D_26.1, D_27.1, D_28.1, U1.B4
row2_L: D_42.1, D_43.1, D_44.1, D_45.1, D_46.1, D_47.1, U2.B3
row2_R: D_35.1, D_36.1, D_37.1, D_38.1, D_39.1, D_40.1, D_41.1, U1.B3
row3_L: D_55.1, D_56.1, D_57.1, D_58.1, D_59.1, D_60.1, U2.B2
row3_R: D_48.1, D_49.1, D_50.1, D_51.1, D_52.1, D_53.1, D_54.1, U1.B2
row4_L: D_69.1, D_70.1, D_71.1, D_72.1, D_73.1, U2.B1
row4_R: D_61.1, D_62.1, D_63.1, D_64.1, D_65.1, D_66.1, D_67.1, D_68.1, U1.B1

## Commit log

2021-01-12 added submodules
2021-01-19 sorted out matrix, upgraded to elite-c, and added underglow leds
2021-01-23 continuing WIP
2021-01-24 lined up rgb leds, WIP on adding bypass capacitors
2021-01-28 rearranged leds, moved caps, adjusting size of keyboard
2021-01-29 laying out traces on the right
2021-02-02 routing WIP
2021-02-04 right side routed
2021-02-07 wiring up oleds and trs. starting left side
2021-02-08 created more traces on left, all grounds first pass
2021-02-10 adding fill areas
2021-02-11 rewiring to make traces more readable
2021-02-12 left side redone. wip on right side and whether or not to add nav section
2021-02-14 redid entire left side
2021-02-15 redoing right side, figuring out reset switch WIP
2021-02-16 wiring done, added more leds, figuring out best place for oled
2021-02-17 wired up and still thinking
2021-02-18 renamed board, added breakaways, renamed some nets
2021-02-18 renamed net, added breakaway tabws
2021-02-19 tabs increased width, double checked schematic with keyboard layout dxf/svg
2021-02-19 moved some leds around, re arranged some traces
2021-02-20 updated rgb lighting based on restrictive pin requirement for underglow and maatrix
2021-02-20 sanity commit
2021-02-20 reannotated everything using auto
2021-02-21 flipped elite-cs, added extra LED
2021-02-21 why are my breakaway tabs missing
2021-02-22 renamed to bakekujira (may still change), added graphics, moved oled up to cover up elite-c
2021-02-22 moved led silkscreens to backside
2021-02-23 switched over to protonc, rewired a bunch of shit, moved oled down to fit
2021-02-24 cleanup, sanity checkin for missing breakaway tabs
2021-02-24 renamed repo
2021-03-06 added images, readme, added holes for acrylic to cover the proton-c
2021-03-29 fixing split and rgb source
2021-04-19 latest sanity upload
2021-05-06 readme and small udpates
2025-11-15 first copy paste commit
2025-11-15 re-rename
